# Keil uVision project test.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Keil_v5\STM32L4\Drivers\CMSIS\Device\ST\STM32L4xx\Include;C:\Keil_v5\STM32L4\Drivers\STM32L4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: main.c startup_stm32l475xx.s system_stm32l4xx.c stm32l4xx_hal_gpio.c stm32l4xx_hal.c stm32l4xx_hal_cortex.c common.h gpio.h gpio.c scheduler.h scheduler.c mutex.h mutex.c tasks.c tasks.h
software components: CMSIS:CORE 5.6.0, Device:CubeMX 1.0.0
